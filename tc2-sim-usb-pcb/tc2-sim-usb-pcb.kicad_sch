File: tc2-sim-usb-pcb/tc2-sim-usb-pcb.kicad_sch (KiCad schematic)
At the start: 9 parts, among them J501 Conn_01x08

Commit message: Upgrade to KiCAD 10
Parts:
- U501, U502, U503: value ~ -> (none)
